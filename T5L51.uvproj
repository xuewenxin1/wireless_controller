# Keil uVision project T5L51.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\obj\1.bat
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\T5L51;.\mcu_sdk
  group Source Group 1
    ./: STARTUP_M5.A51 main.c sys.c control.c uart.c modbus.c rtc.c ErrorHistory.c upload.c
  group WIFI
    ./: Wifipro.c wifi.h OTA.c mcu_api.c protocol.c system.c
